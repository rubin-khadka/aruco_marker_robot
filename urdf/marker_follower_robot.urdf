Commit message: update old files

File: urdf/marker_follower_robot.urdf (robot description, URDF)
Before this commit: robot marker_follower_robot, 10 links, 9 joints
Joints:
- joint footprint_base_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 0
